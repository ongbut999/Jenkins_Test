/* ---------------------------------------------------------------------------*/

  /begin COMPU_METHOD ident 
	"" 
	RAT_FUNC 
	"%8.4" 
	"" 
	COEFFS 0 1 0 0 0 1 
  /end COMPU_METHOD

/* ---------------------------------------------------------------------------*/
